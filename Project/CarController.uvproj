# Keil uVision project CarController.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CarController
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, __FPU_PRESENT=1, __FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\User;..\Mylib;..\Libraries\CM4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CM4
    ../Libraries/CM4/: system_stm32f4xx.c
    ../Libraries/CM4/Startup/: startup_stm32f40xx.s
  group StdPeriph Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group My Libraries
    ../Mylib/: adc.c buzz.c can.c delay.c led.c pid.c racing.c ELMO.c mapan.c usart3.c bluetooth.c timer1.c timer2.c timer4.c timer3.c mpu6500.c kalman.c print.c lowpassfilter.c trajectory.c ipd.c
  group User
    ../User/: main.c stm32f4xx_it.c stm32f4xx_conf.h
